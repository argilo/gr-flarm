options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: flarm_2chan
    output_language: python
  states: {}

blocks:
- name: bottom_channel
  id: variable
  parameters:
    value: '11'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '868300000'
  states: {}
- name: channels
  id: variable
  parameters:
    value: '2'
  states: {}
- name: corr
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Freq. correction
    start: '-100'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: lp_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '100000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: RTL-SDR Gain
    start: '0'
    step: '0.4'
    stop: '49.6'
    value: '30.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: (800,600)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: flarm-packets.txt
    type: byte
  states: {}
- name: flarm_channel_rx_0
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_channel_rx_0_0
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_packetize_0
  id: flarm_packetize
  parameters:
    first_channel: bottom_channel
    num_channels: channels
    reflat: '52.1901640'
    reflon: '5.1512750'
    rxid: '00'
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '-100000'
    decim: '1'
    samp_rate: samp_rate
    taps: lp_taps
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '100000'
    decim: '1'
    samp_rate: samp_rate
    taps: lp_taps
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '12345'
    type: TCP_SERVER
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '512'
    gui_hint: tab@0
    name: '"FFT Plot"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: tab@1
    name: '"Waterfall Plot"'
    type: complex
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    center_freq0: center_freq
    dc_removal0: 'False'
    driver: rtlsdr
    freq_correction0: corr
    gain0: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,2
    label0: Band spectrum
    label1: Band waterfall
    num_tabs: '2'
  states: {}

connections:
- [flarm_channel_rx_0, '0', flarm_packetize_0, '0']
- [flarm_channel_rx_0_0, '0', flarm_packetize_0, '1']
- [flarm_packetize_0, '0', blocks_file_sink_0, '0']
- [flarm_packetize_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', flarm_channel_rx_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', flarm_channel_rx_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, network_socket_pdu_0, pdus]
- [soapy_custom_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [soapy_custom_source_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [soapy_custom_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_custom_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-124-g0d60e80d
