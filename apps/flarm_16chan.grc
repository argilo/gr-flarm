options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: flarm_16chan
    output_language: python
  states: {}

blocks:
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: BB Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '62'
    value: '30'
  states: {}
- name: bottom_channel
  id: variable
  parameters:
    value: '24'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 902000000 + (channel_rate * (bottom_channel + (channels / 2)))
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: channels
  id: variable
  parameters:
    value: '16'
  states: {}
- name: corr
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Freq. correction
    orient: Qt.Horizontal
    start: '-100'
    step: '200'
    stop: '100'
    value: '0'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: IF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '40'
    value: '32'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Preamp
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '14'
    value: '14'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: channel_rate * channels
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: channel_rate * (channels - 1) / 2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: flarm-packets.txt
    type: byte
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate / 32000)
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: flarm_channel_rx_0
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_channel_rx_0_0
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_channel_rx_0_0_0
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_channel_rx_0_0_0_0
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_channel_rx_0_0_0_0_0
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_channel_rx_0_0_0_1
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_channel_rx_0_0_1
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_channel_rx_0_0_1_0
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_channel_rx_0_0_2
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_channel_rx_0_1
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_channel_rx_0_1_0
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_channel_rx_0_1_0_0
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_channel_rx_0_1_1
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_channel_rx_0_2
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_channel_rx_0_2_0
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_channel_rx_0_3
  id: flarm_channel_rx
  parameters: {}
  states: {}
- name: flarm_packetize_0
  id: flarm_packetize
  parameters:
    first_channel: bottom_channel
    num_channels: channels
    reflat: '45.10513'
    reflon: '-75.623744'
    rxid: '00'
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    ant0: LNAW
    args: ''
    bb_gain0: bb_gain
    corr0: corr
    freq0: center_freq
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    bus_conns: '[[0,],]'
    ch_map: '[]'
    nchans: channels
    osr: '1.0'
    taps: firdes.gaussian(1, 4 * samp_rate / channel_rate, 0.5, 8 * samp_rate / channel_rate)
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_real_0, '0', audio_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_0, '0', pfb_channelizer_ccf_0, '0']
- [flarm_channel_rx_0, '0', flarm_packetize_0, '0']
- [flarm_channel_rx_0_0, '0', flarm_packetize_0, '1']
- [flarm_channel_rx_0_0_0, '0', flarm_packetize_0, '3']
- [flarm_channel_rx_0_0_0_0, '0', flarm_packetize_0, '7']
- [flarm_channel_rx_0_0_0_0_0, '0', flarm_packetize_0, '15']
- [flarm_channel_rx_0_0_0_1, '0', flarm_packetize_0, '11']
- [flarm_channel_rx_0_0_1, '0', flarm_packetize_0, '5']
- [flarm_channel_rx_0_0_1_0, '0', flarm_packetize_0, '13']
- [flarm_channel_rx_0_0_2, '0', flarm_packetize_0, '9']
- [flarm_channel_rx_0_1, '0', flarm_packetize_0, '2']
- [flarm_channel_rx_0_1_0, '0', flarm_packetize_0, '6']
- [flarm_channel_rx_0_1_0_0, '0', flarm_packetize_0, '14']
- [flarm_channel_rx_0_1_1, '0', flarm_packetize_0, '10']
- [flarm_channel_rx_0_2, '0', flarm_packetize_0, '4']
- [flarm_channel_rx_0_2_0, '0', flarm_packetize_0, '12']
- [flarm_channel_rx_0_3, '0', flarm_packetize_0, '8']
- [flarm_packetize_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_1, '0', blocks_keep_one_in_n_0, '0']
- [osmosdr_source_1, '0', blocks_multiply_xx_0, '1']
- [pfb_channelizer_ccf_0, '0', flarm_channel_rx_0, '0']
- [pfb_channelizer_ccf_0, '1', flarm_channel_rx_0_0, '0']
- [pfb_channelizer_ccf_0, '10', flarm_channel_rx_0_1_1, '0']
- [pfb_channelizer_ccf_0, '11', flarm_channel_rx_0_0_0_1, '0']
- [pfb_channelizer_ccf_0, '12', flarm_channel_rx_0_2_0, '0']
- [pfb_channelizer_ccf_0, '13', flarm_channel_rx_0_0_1_0, '0']
- [pfb_channelizer_ccf_0, '14', flarm_channel_rx_0_1_0_0, '0']
- [pfb_channelizer_ccf_0, '15', flarm_channel_rx_0_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '2', flarm_channel_rx_0_1, '0']
- [pfb_channelizer_ccf_0, '3', flarm_channel_rx_0_0_0, '0']
- [pfb_channelizer_ccf_0, '4', flarm_channel_rx_0_2, '0']
- [pfb_channelizer_ccf_0, '5', flarm_channel_rx_0_0_1, '0']
- [pfb_channelizer_ccf_0, '6', flarm_channel_rx_0_1_0, '0']
- [pfb_channelizer_ccf_0, '7', flarm_channel_rx_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '8', flarm_channel_rx_0_3, '0']
- [pfb_channelizer_ccf_0, '9', flarm_channel_rx_0_0_2, '0']

metadata:
  file_format: 1
