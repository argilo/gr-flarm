options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: flarm_6chan
    output_language: python
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: bottom_channel
  id: variable
  parameters:
    value: '29'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 902000000 + (channel_spacing * (bottom_channel + (channels / 2)))
  states: {}
- name: channel_rate
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: channel_spacing
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: channels
  id: variable
  parameters:
    value: '6'
  states: {}
- name: corr
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Freq. correction
    start: '-100'
    step: '200'
    stop: '100'
    value: '0'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '115000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: RTL-SDR Gain
    start: '0'
    step: '124'
    stop: '49.6'
    value: '49.6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: channel_rate * channels
  states: {}
- name: window_size
  id: variable
  parameters:
    value: (800,600)
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '-channel_rate / (deviation*2*math.pi)'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '-channel_rate / (deviation*2*math.pi)'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '-channel_rate / (deviation*2*math.pi)'
  states: {}
- name: analog_quadrature_demod_cf_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '-channel_rate / (deviation*2*math.pi)'
  states: {}
- name: analog_quadrature_demod_cf_0_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: '-channel_rate / (deviation*2*math.pi)'
  states: {}
- name: analog_quadrature_demod_cf_0_2
  id: analog_quadrature_demod_cf
  parameters:
    gain: '-channel_rate / (deviation*2*math.pi)'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-channel_spacing / 2'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: int(samp_rate / channel_rate)
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: flarm-packets.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: ''
    file: /home/argilo/git/gr-flarm/apps/good.dat
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_2
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.05'
    gain_omega: 0.25*(0.05*0.05)
    mu: '0.5'
    omega: channel_rate / baud_rate
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.05'
    gain_omega: 0.25*(0.05*0.05)
    mu: '0.5'
    omega: channel_rate / baud_rate
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.05'
    gain_omega: 0.25*(0.05*0.05)
    mu: '0.5'
    omega: channel_rate / baud_rate
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_0_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.05'
    gain_omega: 0.25*(0.05*0.05)
    mu: '0.5'
    omega: channel_rate / baud_rate
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_1
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.05'
    gain_omega: 0.25*(0.05*0.05)
    mu: '0.5'
    omega: channel_rate / baud_rate
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0_2
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.05'
    gain_omega: 0.25*(0.05*0.05)
    mu: '0.5'
    omega: channel_rate / baud_rate
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: flarm_packetize_0
  id: flarm_packetize
  parameters:
    first_channel: bottom_channel
    num_channels: '6'
    reflat: '45.10513'
    reflon: '-75.623744'
    rxid: '00'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '12345'
    type: TCP_SERVER
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    ant0: TX/RX
    args: ''
    bb_gain0: '30'
    corr0: corr
    freq0: center_freq
    gain0: rx_gain
    gain_mode0: 'False'
    if_gain0: '40'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[]'
    nchans: channels
    osr: '1.0'
    taps: firdes.gaussian(1, 4 * channels, 0.5, 8 * channels)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: center_freq
    fftsize: '512'
    gui_hint: tab@0
    name: '"FFT Plot"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: tab@1
    name: '"Waterfall Plot"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: channel_rate
    fc: '0'
    fftsize: '512'
    gui_hint: tab@2
    name: '"Waterfall Plot"'
    type: complex
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    center_freq0: center_freq
    driver: uhd
    gain0: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_custom_source_0_0
  id: soapy_custom_source
  parameters:
    agc0: 'True'
    center_freq0: center_freq
    dc_removal0: 'False'
    driver: rtlsdr
    gain0: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,2
    label0: Band spectrum
    label1: Band waterfall
    label2: Channel sum waterfall
    num_tabs: '3'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: rx_gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0_0_0, '0', digital_clock_recovery_mm_xx_0_0_0_0, '0']
- [analog_quadrature_demod_cf_0_1, '0', digital_clock_recovery_mm_xx_0_1, '0']
- [analog_quadrature_demod_cf_0_2, '0', digital_clock_recovery_mm_xx_0_2, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', pfb_channelizer_ccf_0, '0']
- [digital_binary_slicer_fb_0, '0', flarm_packetize_0, '0']
- [digital_binary_slicer_fb_0_0, '0', flarm_packetize_0, '1']
- [digital_binary_slicer_fb_0_0_0, '0', flarm_packetize_0, '4']
- [digital_binary_slicer_fb_0_0_0_0, '0', flarm_packetize_0, '5']
- [digital_binary_slicer_fb_0_1, '0', flarm_packetize_0, '2']
- [digital_binary_slicer_fb_0_2, '0', flarm_packetize_0, '3']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', digital_binary_slicer_fb_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0, '0', digital_binary_slicer_fb_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_0_0_0, '0', digital_binary_slicer_fb_0_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0_1, '0', digital_binary_slicer_fb_0_1, '0']
- [digital_clock_recovery_mm_xx_0_2, '0', digital_binary_slicer_fb_0_2, '0']
- [flarm_packetize_0, '0', blocks_file_sink_0, '0']
- [flarm_packetize_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [osmosdr_source_1, '0', blocks_multiply_xx_0, '0']
- [osmosdr_source_1, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_1, '0', qtgui_waterfall_sink_x_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, network_socket_pdu_0, pdus]
- [pfb_channelizer_ccf_0, '0', analog_quadrature_demod_cf_0, '0']
- [pfb_channelizer_ccf_0, '0', blocks_add_xx_0, '0']
- [pfb_channelizer_ccf_0, '1', analog_quadrature_demod_cf_0_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_add_xx_0, '1']
- [pfb_channelizer_ccf_0, '2', analog_quadrature_demod_cf_0_1, '0']
- [pfb_channelizer_ccf_0, '2', blocks_add_xx_0, '2']
- [pfb_channelizer_ccf_0, '3', analog_quadrature_demod_cf_0_2, '0']
- [pfb_channelizer_ccf_0, '3', blocks_add_xx_0, '3']
- [pfb_channelizer_ccf_0, '4', analog_quadrature_demod_cf_0_0_0, '0']
- [pfb_channelizer_ccf_0, '4', blocks_add_xx_0, '4']
- [pfb_channelizer_ccf_0, '5', analog_quadrature_demod_cf_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '5', blocks_add_xx_0, '5']
- [soapy_custom_source_0, '0', blocks_multiply_xx_0, '0']
- [soapy_custom_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_custom_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_custom_source_0_0, '0', blocks_multiply_xx_0, '0']
- [soapy_custom_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_custom_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-124-g0d60e80d
