<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>flarm_28chan</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bottom_channel</value></param>
<param><key>value</key><value>18</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_rate</value></param>
<param><key>value</key><value>400000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channels</value></param>
<param><key>value</key><value>28</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>channel_rate * channels</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>902000000 + (channel_rate * (bottom_channel + (channels / 2)))</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_1</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>corr0</key><value>corr</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>20</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_0</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_1</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_0_0</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>corr</value></param>
<param><key>label</key><value>Freq. correction</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-100</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>label</key><value>RTL-SDR Gain</value></param>
<param><key>value</key><value>49.6</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>49.6</value></param>
<param><key>num_steps</key><value>124</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>channel_rate * (channels - 1) / 2</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_0_1</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_1_0</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_0_0_0</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_3</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_0_2</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_1_1</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_0_0_1</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_2_0</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_0_1_0</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_1_0_0</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_0_0_0_0</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_4</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_0_3</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_1_2</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_0_0_2</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_2_1</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_0_1_1</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_1_0_1</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_0_0_0_1</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_3_0</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_0_2_0</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_1_1_0</value></param>
</block>
<block>
<key>flarm_channel_rx</key>
<param><key>id</key><value>flarm_channel_rx_0_0_0_1_0</value></param>
</block>
<block>
<key>flarm_packetize</key>
<param><key>id</key><value>flarm_packetize_0</value></param>
<param><key>num_channels</key><value>channels</value></param>
<param><key>first_channel</key><value>bottom_channel</value></param>
<param><key>rxid</key><value>00</value></param>
<param><key>reflat</key><value>45.10513</value></param>
<param><key>reflon</key><value>-75.623744</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>flarm-packets.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>append</key><value>True</value></param>
</block>
<block>
<key>pfb_channelizer_ccf</key>
<param><key>id</key><value>pfb_channelizer_ccf_0</value></param>
<param><key>nchans</key><value>channels</value></param>
<param><key>taps</key><value>firdes.gaussian(1, 4 * samp_rate / channel_rate, 0.5, 8 * samp_rate / channel_rate)</value></param>
<param><key>osr</key><value>1.0</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>ch_map</key><value>[]</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_0_0_1_0</sink_block_id><source_key>27</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_1_1_0</sink_block_id><source_key>26</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_0_2_0</sink_block_id><source_key>25</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_3_0</sink_block_id><source_key>24</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_0_0_0_1</sink_block_id><source_key>23</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_1_0_1</sink_block_id><source_key>22</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_0_1_1</sink_block_id><source_key>21</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_2_1</sink_block_id><source_key>20</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_0_0_2</sink_block_id><source_key>19</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_1_2</sink_block_id><source_key>18</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_0_3</sink_block_id><source_key>17</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_4</sink_block_id><source_key>16</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_0_0_0_0</sink_block_id><source_key>15</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_1_0_0</sink_block_id><source_key>14</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_0_1_0</sink_block_id><source_key>13</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_2_0</sink_block_id><source_key>12</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_0_0_1</sink_block_id><source_key>11</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_1_1</sink_block_id><source_key>10</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_0_2</sink_block_id><source_key>9</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_3</sink_block_id><source_key>8</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_2</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_0_1</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_1_0</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_0_0_0</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0_1</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_channelizer_ccf_0</source_block_id><sink_block_id>flarm_channel_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>pfb_channelizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_0</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_1</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_0_0</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_2</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_0_1</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_1_0</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_0_0_0</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_3</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_0_2</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_1_1</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>10</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_0_0_1</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>11</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_2_0</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>12</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_0_1_0</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>13</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_1_0_0</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>14</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_0_0_0_0</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>15</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_4</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>16</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_0_3</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>17</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_1_2</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>18</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_0_0_2</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>19</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_2_1</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>20</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_0_1_1</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>21</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_1_0_1</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>22</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_0_0_0_1</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>23</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_3_0</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>24</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_0_2_0</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>25</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_1_1_0</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>26</sink_key></connection>
<connection><source_block_id>flarm_channel_rx_0_0_0_1_0</source_block_id><sink_block_id>flarm_packetize_0</sink_block_id><source_key>0</source_key><sink_key>27</sink_key></connection>
<connection><source_block_id>flarm_packetize_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
